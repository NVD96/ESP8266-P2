# Keil uVision project CH579_Demo.uvprojx, settings and files
target CH579_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH579_Demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c include: ..\HareWare\inc;..\SRC\StdPeriphDriver\inc;..\User;..\SRC\CMSIS\Include;..\lwip-2.1.2\src\include;..\lwip-2.1.2\src\include\lwip\apps;..\lwip-2.1.2\src\include\lwip\priv;..\lwip-2.1.2\src\include\lwip;..\lwip-2.1.2\src\netif;..\lwip-2.1.2\src;..\lwip-2.1.2\src\arch;..\Net\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: Main.c
  group Peripheral
    ../SRC/StdPeriphDriver/: CH57x_adc.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_uart0.c CH57x_clk.c CH57x_timer0.c
  group HareWare
    ../HareWare/src/: mybufque.c parameter_setting.c ethernetif.c
  group Startup
    ../SRC/Startup/: startup_ARMCM0.s
  group Lwip/api
    ../lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/core
    ../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lwip/netif
    ../lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c
  group Lwip/arch
    ../lwip-2.1.2/src/arch/: sys_arch.c
  group Net
    ../Net/scr/: lwipcomm.c mych579mac.c mytcpserver.c
