		org 0
		MOV TMOD, #01
		MOV R0, #0
MAIN:
	  	CLR P2.0
		JNB P2.1, SOSANH
SO1:
		SJMP MAIN
SOSANH:
		CALL DELAY
		JNB P2.1, NHAN
SO2:
		JMP SO1
NHAN:
		MOV A, R0
;		CALL HIENTHI
;		RET
;HIENTHI:
		MOV DPTR, #MALED
		MOVC A, @A+DPTR
		MOV P3, A
		INC R0
		JMP SO2
DELAY:
		MOV TH0, #HIGH(-200)
		MOV TL0, #LOW(-200)
		SETB TR0
		JNB TF0, $
		CLR TR0
		CLR TF0
		RET
		ORG 300H
MALED:
		DB 0C0H, 0F9H, 0A4H, 0B0H, 99H, 92H, 82H, 0F8H, 80H, 90H, 88H, 83H, 0C6H, 0A1H, 86H, 8EH
		END
