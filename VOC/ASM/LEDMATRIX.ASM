	ORG 0
	MOV TMOD, #01
	MOV R7, #200
CT: 
	MOV DPTR, #MALED
	MOV R2, #1
MAIN:
	MOV R0, #0
	MOV P2, #00000001B
QUETCOT:
	MOV A, R0
	MOVC A, @A+DPTR
	MOV P1, A
	INC R0
	CALL DELAY
	MOV A, P2
	RL A
	MOV P2, A
	CJNE A, #00000001B, QUETCOT
;	DJNZ  R2, MAIN
	INC DPTR
	MOV A, DPL
	CJNE A, #40, MAIN
	SJMP CT
DELAY:
	CALL DELAY1
	DJNZ R7, DELAY
	RET
DELAY1:
	 MOV TH0, #HIGH(-20)
	 MOV TL0, #LOW(-20)
	 SETB TR0
	 JNB TF0, $
	 CLR TR0
	 CLR TF0
	 RET
;CHAYLED:
;	DB  80H,40H,20H,10H,08H,04H,02H,01H,00H
	ORG 500H
MALED:
	DB  0FFH, 0FFH, 0FFH,0FFH,0FFH,0FFH,0FFH,0FFH
	DB 	00H,00H,0F9H,0F3H,0E7H,0CFH,00H,00H		 ; CHU N
	DB  0FFH, 0FFH, 0FFH,0FFH	   				 ; KHOANG TRONG	
	DB  0FFH,0C0H,80H,3FH,3FH,80H,0C0H,0FFH		  ; CHU V
	DB  0FFH, 0FFH, 0FFH,0FFH						; KHOANG TRONG
	DB  0E7H,00H,00H,24H,24H,3CH,00H,81H		 ; CHU DD
	DB  0FFH, 0FFH, 0FFH,0FFH,0FFH,0FFH,0FFH,0FFH	; KHOANG TRONG
	 END